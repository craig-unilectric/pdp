# Keil uVision project PDP_proc.uvproj, settings and files
target PDP_proc Configuration (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: PDP_proc Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc;             ..\Drivers\STM32F4xx_HAL_Driver\Inc;             ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;             ..\Drivers\CMSIS\Include;             ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c usart.c gpio.c spi.c adc.c dma.c main.c tim.c stm32f4xx_hal_msp.c i2c.c
  group User
    ../Src/: uni_command.h uni_defines.h uni_DISCO_pins.h uni_EVAL_pins.h uni_memory.h uni_types.h uni_adc.c uni_command.c uni_power.c uni_relay.c uni_uart.c uni_eeprom.c uni_voltage.c
    ../../uni_host/: fc_host_commands.h uni_host_structs.h
